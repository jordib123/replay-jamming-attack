<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-70e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>50e3</value></param>
<param><key>low_cutoff_freq</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>high</key><value>4e-3</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>4e-3</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>custom_file_sink</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import sched, time
import osmosdr
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    def __init__(self, sink='/home/jordi/Desktop/signal.raw'):
        gr.sync_block.__init__(
            self,
            name='Custom File Sink', 
            in_sig=[np.complex64, np.complex64, np.float32],
            out_sig=[np.complex64]
        )
	self.first_signal = None
	self.sink = open(sink, 'w+b')
	self.first_signal_captured = False
	self.detected = False
	self.transmit = False
	self.finished = False
	self.timer = 0


    def work(self, input_items, output_items):
	input_jam = input_items[0] # Jamming signal
	input_sig = input_items[1] # Osmocom captured signal
	input_detect = input_items[2] # Signal detection

	# Transmit first captured key fob signal
	if self.transmit:
	    output_items[0][:] = self.transmit_signal(len(output_items[0]))
	else:
	    output_items[0][:] = input_jam 

	if not self.finished:
	    self.process_input(input_detect, input_sig)

	return len(output_items[0])


    def process_input(self, input_detect, input_sig):
	"""

	Function checks if a key fob signal is detected (1 in input_detect).
	If True, save first packet of input signal (key fob signal) and set 'detected' Boolean to True (for 1 second).
	If key fob signal was already detected in previous packets ('detected' = True), save input packet to corresponding sink.
	
	Parameters:
	    input_detect (np.ndarray): input signal used for detection of the key fob signal
	    input_sig (np.ndarray): raw radio frequency signal captured by SDR
	"""
	if self.detected:
	    self.save(input_sig)
	    self.check_timer()
	elif 1 in input_detect:
	    if self.first_signal_captured:
		self.sink.write(bytearray(input_sig))
		self.transmit = True
	    else:
		self.first_signal = input_sig
	    self.start_timer()


    def transmit_signal(self, length):
	"""

	Function creates np.ndarray of length 'length' parameter consisting of the first captured key fob signal.
	
	Parameters:
	    length (int): length of output_items array

	Returns:
	    np.ndarray: ndarray consisting of captured key fob signal (+ additional padding if captured key fob signal is to short for packet)
	"""
	result = np.pad(self.first_signal[:length], (0, length - len(self.first_signal[:length])), 'constant')
	self.first_signal = self.first_signal[length:]
	return result


    def save(self, data):
	"""

	Function saves input signal to corresponding sink:
	First key fob signal is saved to variable
	Second key fob signal is saved to file (for later use)
	
	Parameters:
	    data (np.ndarray): input signal that has to be saved
	"""
	if not self.first_signal_captured:
	    self.first_signal = np.concatenate((self.first_signal, data))
	else:
	    self.sink.write(bytearray(data))


    def start_timer(self):
	"""Function starts timer upon detecting a key fob signal"""
	self.timer = int(round(time.time() * 1000))
	self.detected = True


    def check_timer(self):
	"""

	Function checks if timer's value &gt; 1000 ms:
	If timer &gt; 1000, stop saving the input signal
	If timer &lt; 1000, do nothing (=keep saving input signal)

	"""
	curr_time = int(round(time.time() * 1000))
	if (curr_time - self.timer) &gt;= 1000:
	    print('Signal captured')
	    if self.first_signal_captured:
		self.sink.close()
		self.finished = True
	    self.detected = False 
	    self.first_signal_captured = True

</value></param>
<param><key>sink</key><value>'/home/jordi/Desktop/Masterproef/masterproef/rolljam_hackrf_gnu/signal.raw'</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>custom_file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>custom_file_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>custom_file_sink</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>custom_file_sink</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
